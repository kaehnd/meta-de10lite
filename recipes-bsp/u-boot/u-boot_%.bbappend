FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Files-for-DE10Lite.patch \
            file://devtool-fragment.cfg \
            "

