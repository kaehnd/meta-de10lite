SRC_URI:remove = "file://0001-Make-CPU-family-warnings-fatal.patch"
