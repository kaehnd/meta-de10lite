COMPATIBLE_HOST = "nios2-poky-linux"