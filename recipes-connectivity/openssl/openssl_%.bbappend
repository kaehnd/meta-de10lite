CFLAGS:append = "-DBROKEN_CLANG_ATOMICS"
